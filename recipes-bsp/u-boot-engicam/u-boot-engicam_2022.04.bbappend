FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-changed-CONFIG_DEFAULT_FDT_FILE-to-imx8mp-icore-fast.patch"

